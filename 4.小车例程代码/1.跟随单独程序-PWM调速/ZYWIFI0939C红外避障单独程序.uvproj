# Keil uVision project ZYWIFI0939C红外避障单独程序.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1、ZYWIFI0939C 跟随单独程序-PWM调速 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c ZY-4WD_PWM.h
