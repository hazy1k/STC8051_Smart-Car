# Keil uVision project ZYWIFI0939C红外遥控控制小车程序.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ZYWIFI0939C红外遥控控制小车程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ZYWIFI0939C红外遥控控制小车程序.C ZY-4WD_PWM.h
