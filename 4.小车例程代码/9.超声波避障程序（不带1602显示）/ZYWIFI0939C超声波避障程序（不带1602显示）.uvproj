# Keil uVision project ZYWIFI0939C超声波避障程序（不带1602显示）.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODAT2
  output: ZYWIFI0939C超声波避障程序（不带1602显示） +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ZYWIFI0939C超声波避障程序（不带1602显示）.c
