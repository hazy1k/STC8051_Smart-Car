	ORG 0000H
	AJMP MAIN
	ORG 030H
MAIN:	MOV P2,#0FFH
	MOV A,#0FFH
	MOV P1,A
	MOV A,P1
	CJNE A,#0FFH,GO1
	AJMP MAIN
GO1:	ACALL DEL
	CJNE A,#0FFH,GO2
	AJMP MAIN
GO2:	MOV DPTR,#TAB
	MOV R0,#00H
L1:	RRC A
	JNC N1
	INC R0
	SJMP L1
N1:	MOV A,R0
	RLC A
	JMP @A+DPTR
TAB:	AJMP PR0
	AJMP PR1
	AJMP PR2
	AJMP PR3
	AJMP PR4
	AJMP PR5
	AJMP PR6
	AJMP PR7
PR0:	MOV P2,#0FEH
	ACALL DEL
	AJMP MAIN
PR1:	MOV P2,#0FCH
	ACALL DEL
	AJMP MAIN
PR2:	MOV P2,#0F8H
	ACALL DEL
	AJMP MAIN
PR3:	MOV P2,#0F0H
	ACALL DEL 
	AJMP MAIN
PR4:	MOV P2,#0E0H
	ACALL DEL 
	AJMP MAIN
PR5:	MOV P2,#0C0H
	ACALL DEL 
	AJMP MAIN
PR6:	MOV P2,#80H
	ACALL DEL 
	JMP MAIN
PR7:	MOV P2,#00H
	ACALL DEL 
	AJMP MAIN
DEL: 	MOV R7,#0FFH
DEL1:	MOV R6,#0FFH
DEL2:	DJNZ R6,DEL2
     	DJNZ R7,DEL1
     	RET
	END