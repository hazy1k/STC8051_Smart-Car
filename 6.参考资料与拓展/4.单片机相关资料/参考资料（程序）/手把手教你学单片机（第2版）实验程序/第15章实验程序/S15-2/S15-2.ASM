	ORG 0000H
	AJMP MAIN
	ORG 030H
MAIN:	MOV P0,#0FFH
START:	MOV P3,#0FH
	MOV A,P3
	CJNE A,#0FH,GO1
	MOV A,R1
	MOV DPTR,#TAB
	MOVC A,@A+DPTR
	MOV P0,A
	ACALL DEL
	AJMP START
GO1:	ACALL DEL
	CJNE A,#0FH,GO2
	AJMP START 
GO2:	MOV R2,#0DFH
	MOV R0,#00H
ST:	MOV P3,R2
	MOV A,P3
	JB ACC.0,ONE
	MOV A,#01H
	AJMP LKP
ONE:	JB ACC.1,TWO
	MOV A,#04H
	AJMP LKP
TWO:	JB ACC.2,THR
	MOV A,#07H
	AJMP LKP
THR:	JB ACC.3,NEXT
	MOV A,#0AH
LKP:	ADD A,R0
	CJNE A,#0BH,LKP1
	MOV A,#00H
LKP1:	MOV R1,A
	AJMP START
NEXT:	INC R0
	CJNE R0,#03H,L1
	MOV R0,#00H
	AJMP ST
L1:	CJNE R2, #0DFH ,L2
	MOV R2, #0BFH 
	AJMP ST
L2:	CJNE R2, #0BFH ,L3
	MOV R2, #7FH 
	AJMP ST
L3:	CJNE R2, #7FH ,RE
	MOV R2,#0DFH
RE:	AJMP START
DEL: 	MOV R7,#0DH
DEL1:	MOV R6,#0FFH
DEL2:	DJNZ R6,DEL2
     	DJNZ R7,DEL1
     	RET
TAB:	DB 0C0H,0F9H,0A4H,0B0H,99H,92H,82H,0F8H,80H,90H
	END