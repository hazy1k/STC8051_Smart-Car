	ORG 0000H
	AJMP MAIN
	ORG 000BH
	AJMP CTC0
	ORG 0030H
MAIN:	MOV TMOD,#00H
	MOV TL0,#0FFH
	MOV TH0,#0FFH
	SETB EA
	SETB ET0
	SETB TR0
GOON:	MOV P0,#00H
	ACALL DEL25S
	MOV P0,#0FFH
	ACALL DEL25S
	AJMP GOON
CTC0:	MOV TL0,#0FFH
	MOV TH0,#0FFH
	JB P3.0,RE
	CLR TR0
	CPL C
	JC NEXT
	MOV P1,#00H
	AJMP NEXT1
NEXT:	MOV P1,#0FFH
NEXT1:	ACALL DEL1S
	SETB TR0
RE:	RETI
DEL1S:	MOV R5,#0FFH
F1:	MOV R6,#0FFH
F2:	DJNZ R6,F2
	DJNZ R5,F1
	RET
DEL25S:	MOV R0,0AH
LOOP:	ACALL DEL1S
	DJNZ R0,LOOP
	RET
	END

