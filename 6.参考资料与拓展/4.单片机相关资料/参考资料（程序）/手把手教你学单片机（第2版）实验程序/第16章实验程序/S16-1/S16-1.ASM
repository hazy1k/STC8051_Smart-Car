	ORG 0000H
	LJMP MAIN
	ORG 030H
MAIN:	MOV 20H,#00H
	MOV A,20H
	MOV P3,#92H
	MOV P2,#82H
GOON:	CLR C
	ANL A,#0FH
	MOV DPTR,#TAB
	MOVC A,@A+DPTR
	MOV P0,A
	MOV A,20H
	SWAP  A
	ANL A,#0FH
	MOVC A,@A+DPTR
	MOV P1,A
	ACALL DEL
	MOV A,20H
	INC A
	DA A
	MOV 20H, A
	AJMP GOON
DEL: 	MOV R7,#014H
DEL1:	MOV R6,#0FFH
DEL2:   MOV R5,#01FH
DEL3:	DJNZ R5,DEL3
	DJNZ R6,DEL2
	DJNZ R7,DEL1
	RET
	ORG 0100H
TAB:	DB 0C0H,0F9H,0A4H,0B0H,99H,92H,82H,0F8H
	DB 80H,90H,88H,83H,0C6H,0A1H,86H,08EH
	END
