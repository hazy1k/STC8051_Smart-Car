	ORG 0000H
	LJMP MAIN
	ORG 030H
MAIN:	MOV A,#0C3H
  	MOV R0,#0AAH
       	CPL A
	MOV P0,A
	MOV A,#0C3H
	ANL A,R0
	MOV P1,A
	MOV A,#0C3H
	ORL A,R0
	MOV P2,A
	MOV A,#0C3H
	XRL A,R0
	MOV P3,A
	ACALL DEL
	AJMP MAIN
DEL: 	MOV R7,#0FFH
DEL1:	MOV R6,#0FFH
DEL2:   MOV R5,#01FH
DEL3:	DJNZ R5,DEL3
	DJNZ R6,DEL2
	DJNZ R7,DEL1
	RET
	END
