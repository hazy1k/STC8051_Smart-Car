	BIT_FLAG BIT 20H.0
	X DATA 30H
	ORG 0000H
	LJMP MAIN
	ORG 0003H 
	LJMP 0200H
	ORG 030H
MAIN:	MOV X,#00H
	SETB BIT_FLAG
	MOV P0,#0FFH 
ST:	CLR P3.5 
	SETB IT0 
	SETB EX0 
	SETB EA 
	JNB BIT_FLAG,NEXT
	MOV A,X
	INC A
	CJNE A,#0AH,SF
	MOV A,#00H 
SF:	MOV X,A 
NEXT:	MOV A,X
	MOV DPTR,#TAB
	MOVC A,@A+DPTR 
	MOV P0,A 
	ACALL DEL0_5S 
	AJMP ST 
	ORG 0200H 
	CPL BIT_FLAG 
	RETI 
DEL4MS: MOV R7,#04H 
DL0:	MOV R6,#0FFH
DL1:	DJNZ R6,DL1
	DJNZ R7,DL0
	RET
DEL0_5S:MOV R5,0FFH 
FX:	ACALL DEL4MS
	DJNZ R5,FX
	RET
TAB:	DB 0C0H,0F9H,0A4H,0B0H,099H 
	DB 092H,082H,0F8H,080H,090H
	END
