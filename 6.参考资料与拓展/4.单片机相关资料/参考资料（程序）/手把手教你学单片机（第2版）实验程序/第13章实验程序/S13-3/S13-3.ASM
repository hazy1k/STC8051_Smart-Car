	ORG 0000H
	LJMP MAIN
	ORG 0003H
	LJMP INSER0
	ORG 0013H
	LJMP INSER1
	ORG 030H
MAIN:	MOV SP,#70H
	MOV IE,#85H
	SETB PX1
LOOP:	MOV P0,#00H
	MOV P1,#0FFH
	MOV P2,#0FFH
	SJMP LOOP
	ORG 0100H
INSER0:	MOV R5,#3FH 
DS0:	MOV P0,#0FFH
	MOV P1,#00H
	MOV P2,#0FFH
	LCALL DEL
	DJNZ R5,DS0
	RETI
	ORG 0150H
INSER1:	MOV A,R5
	PUSH ACC
	MOV R5,#0FH 
DS1:	MOV P0,#0FFH
	MOV P1,#0FFH
	MOV P2,#00H
	LCALL DEL
	DJNZ R5,DS1
	POP ACC
	MOV R5,A
	RETI
	ORG 0200H
DEL:	MOV R4,#0FFH
DEL1:	MOV R3,#0FFH
DEL2:	DJNZ R3,DEL2
	DJNZ R4,DEL1
   	RET
	END
