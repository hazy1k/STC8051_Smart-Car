	ORG 0000H
	LJMP MAIN
	ORG 0003H
	LJMP ZD0
	ORG 0013H
	LJMP ZD1
	ORG 030H
MAIN:	MOV SP,#70H
	MOV IE,#85H
LOOP:	SETB P1.1
	SETB P1.2
	CLR P1.0
	SETB P1.3
	SETB P1.4
	CLR P1.5
	ACALL DEL90S
	ACALL YELL
	ACALL DEL2S
	SETB P1.0
	SETB P1.1
	CLR P1.2
	SETB P1.4
	SETB P1.5
	CLR P1.3
	ACALL DEL90S
	ACALL YELL
	ACALL DEL2S
	SJMP LOOP
YELL:	SETB P1.0
	SETB P1.2
	CLR P1.1
	SETB P1.3
	SETB P1.5
	CLR P1.4
	RET
ZD0:	CLR P1.0 
	SETB P1.1
	SETB P1.2
	SETB P1.3
	SETB P1.4
	CLR P1.5
	JNB P3.2,ZD0
	RETI
ZD1:	CLR P1.3 
	CLR P1.2
	SETB P1.1
	SETB P1.0
	SETB P1.4
	SETB P1.5
	JNB P3.3,ZD1
	RETI
DEL2S: 	MOV R5,#10H
F3:	MOV R6,#0FFH
F2:	MOV R7,#0E1H
F1:	DJNZ R7,F1
	DJNZ R6,F2
	DJNZ R5,F3
	RET
DEL90S:	MOV R5,#03H
F6:	MOV R6,#0F0H
F5:	MOV R7,#0F0H
F4:	MOV R0,#0F0H
	DJNZ R0,$
	DJNZ R7,F4
	DJNZ R6,F5
	DJNZ R5,F6
	RET
	END
