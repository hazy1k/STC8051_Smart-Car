	ORG 0000H
	LJMP MAIN
	ORG 030H
MAIN:	CLR P0.7
	ACALL DEL
	SETB P0.7
	CLR P0.6
	ACALL DEL
	SETB P0.6   
	CLR P0.5
	ACALL DEL
	SETB P0.5
	CLR P0.4
	ACALL DEL
	SETB P0.4
	CLR P0.3
	ACALL DEL
	SETB P0.3
	CLR P0.2
	ACALL DEL
	SETB P0.2
	CLR P0.1
	ACALL DEL
	SETB P0.1
	CLR P0.0
	ACALL DEL
	SETB P0.0
	AJMP MAIN
DEL: 	MOV R7,#0FFH
DEL1:	MOV R6,#0FFH
DEL2:   MOV R5,#01FH
DEL3:	DJNZ R5,DEL3
	DJNZ R6,DEL2
	DJNZ R7,DEL1
	RET
	END
