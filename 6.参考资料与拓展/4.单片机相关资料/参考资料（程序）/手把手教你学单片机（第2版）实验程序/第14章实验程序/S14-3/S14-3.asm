		ORG 0000H
		LJMP MAIN
		ORG 030H
MAIN:	MOV R2,#40
		MOV R1,#00H
		MOV R0,#20H
THERE:MOV A,R1
		MOV @R0,A
		INC R0  
		INC R1
		DJNZ R2, THERE
		MOV R2,#40
		MOV R0,#20H
		MOV R1,#50H
LOOP:	MOV A,@R0
		CJNE A,#24H,LOOP2
		MOV P1,A
		ACALL DEL
		AJMP LOOP1
LOOP2:MOV @R1,A
		MOV P0,A
		ACALL DEL
		INC R0
		INC R1
		DJNZ R2,LOOP
LOOP1:SJMP $
DEL: 	MOV R7,#0FFH
DEL1:	MOV R6,#0FFH
DEL2: MOV R5,#08H
DEL3:	DJNZ R5,DEL3
		DJNZ R6,DEL2
		DJNZ R7,DEL1
		RET
		END
