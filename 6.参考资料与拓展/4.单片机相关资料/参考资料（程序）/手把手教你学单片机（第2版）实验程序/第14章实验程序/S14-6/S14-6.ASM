	ORG 0000H
	LJMP MAIN
	ORG 0BH
	MOV TH0,R1
	MOV TL0,R0
	CPL P1.7
	RETI
	ORG 0100H
MAIN:	MOV TMOD,#01H
	MOV IE,#82H
	MOV DPTR,#TAB
LOOP:	CLR A
	MOVC A,@A+DPTR 
	MOV R1,A
	INC DPTR
	CLR A
	MOVC A,@A+DPTR 
	MOV R0,A
	ORL A,R1
	JZ NEXT0
	MOV A,R0
	ANL A,R1
	CJNE A,#0FFH,NEXT
	SJMP MAIN
NEXT:	MOV TH0,R1
	MOV TL0,R0
	SETB TR0
	SJMP NEXT1
NEXT0:	CLR TR0
NEXT1:	CLR A
	INC DPTR
	MOVC A,@A+DPTR 
	MOV R2,A
LOOP1:	ACALL D200
	DJNZ	R2,LOOP1
	INC DPTR
	AJMP LOOP
D200:	MOV R3,#81H
D200B:	MOV A,#0FFH
D200A:	DEC A
	JNZ D200A
	DEC R3
	CJNE R3,#00H,D200B
	RET
TAB:	DB 0FEH,25H,02H,0FEH,25H,02H 
	DB 0FEH,25H,04H,0FDH,80H,04H
	DB 0FEH,84H,02H,0FEH,84H,02H
	DB 0FEH,84H,04H,0FEH,25H,04H
	DB 0FEH,25H,02H,0FEH,84H,02H
	DB 0FEH,0C0H,04H,0FEH,0C0H,04H
	DB 0FEH,98H,02H,0FEH,84H,02H
	DB 0FEH,57H,08H,00H,00H,04H
	DB 0FFH,0FFH
	END
