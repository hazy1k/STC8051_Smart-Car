	ORG 0000H
	LJMP MAIN
	ORG 0030H
MAIN:	MOV 20H,#50H
	MOV 21H,#38H
	MOV 22H,#07H
	MOV 23H,#13H
	MOV 24H,#59H
	MOV 25H,#44H
	MOV 26H,#78H
	MOV 27H,#22H
SORT:	MOV R0,#20H
	MOV R7,#07H
	CLR TR0
LOOP:   MOV A,@R0
	MOV 2BH,A
	INC R0
	MOV 2AH,@R0
	CLR C
	SUBB A,@R0
	JC NEXT
        MOV @R0,2BH
	DEC R0
	MOV @R0,2AH
	INC R0
	SETB TR0
NEXT:  DJNZ R7,LOOP
	JB TR0,SORT
	CLR P1.0
	ACALL DEL
	MOV R0,#20H
HERE:  JB P1.7,HERE
	MOV P0,@R0
	INC R0
	ACALL DEL
	CJNE R0,#28H,HERE
	SJMP $
DEL:	MOV R5,#04H
F3:	MOV R6,#0FFH
F2:	MOV R7,#0FFH
F1:	DJNZ R7,F1
	DJNZ R6,F2
	DJNZ R5,F3
	RET
	END