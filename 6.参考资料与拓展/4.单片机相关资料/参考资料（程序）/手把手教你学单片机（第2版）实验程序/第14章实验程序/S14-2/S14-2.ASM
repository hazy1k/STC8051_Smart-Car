	LEN DATA 30H
	MAX DATA 35H
	BLOCK DATA 40H
	ORG 0000H
	LJMP MAIN
	ORG 030H
MAIN:	MOV LEN,#10
	MOV A,#100
	MOV R1,#BLOCK
LOOP1:	MOV @R1,A
	INC R1 
	INC A
	DJNZ LEN,LOOP1
	MOV LEN,#15   
	MOV A,#50
LOOP2:	MOV @R1,A
	INC R1
	INC A
	DJNZ LEN,LOOP2
	CLR A
	MOV LEN,#25
	MOV R2,LEN
	MOV R1,#BLOCK
LOOP:	CLR C
	SUBB A,@R1
	JNC NEXT1
	MOV A,@R1
	SJMP NEXT2
NEXT1:	ADD A,@R1
NEXT2:  INC R1
	DJNZ R2,LOOP
	MOV MAX,A
	MOV P1,MAX
	ACALL DEL
	SJMP $
DEL: 	MOV R7,#0FFH
DEL1:	MOV R6,#0FFH
DEL2:   MOV R5,#1FH
DEL3:	DJNZ R5,DEL3
	DJNZ R6,DEL2
	DJNZ R7,DEL1
	RET
	END
