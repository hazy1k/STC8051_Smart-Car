	ORG 0000H
	LJMP MAIN
	ORG 030H
 MAIN: 	MOV P3,#0C0H
	ACALL DEL4MS
	MOV P3,#0F0H
	MOV A,P3
	CJNE A,#0F0H,F1
	AJMP MAIN
F1:	MOV P3,#0F9H
	ACALL DEL1S
	MOV P3,#0A4H
	ACALL DEL1S
	MOV P3,#0B0H
	ACALL DEL1S
	MOV P3,#099H
	ACALL DEL1S
	MOV P3,#092H
	ACALL DEL1S
	MOV P3,#082H
	ACALL DEL1S
	MOV P3,#0F8H
	ACALL DEL1S
	MOV P3,#080H
	ACALL DEL1S
	MOV P3,#090H
	ACALL DEL1S
	AJMP MAIN
DEL4MS: MOV R7,#04H
DL0:	MOV R6,#0FFH
DL1:	DJNZ R6,DL1
	DJNZ R7,DL0
	RET
DEL1S:  MOV R5,#0FFH
F2:	ACALL DEL4MS
	DJNZ R5,F2
	RET
	END
