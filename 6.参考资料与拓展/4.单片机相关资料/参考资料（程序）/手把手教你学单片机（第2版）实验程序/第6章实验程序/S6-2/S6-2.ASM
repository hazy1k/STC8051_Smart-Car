	ORG 0000H
	AJMP MAIN
	ORG 030H
MAIN:	MOV P0,#0FEH
	ACALL DELX
	MOV P0,#0FFH
	ACALL DELX
	MOV P0,#0FEH
	ACALL DELY
	MOV P0,#0FFH
	ACALL DELY
	MOV P0,#0FEH
	ACALL DELZ
	MOV P0,#0FFH
	ACALL DELZ
	AJMP MAIN
DELX:	MOV R5,#02H
DELX1:	MOV R6,#0FFH
DELX2:	MOV R7,#0FFH
DELX3:	DJNZ R7, DELX3
	DJNZ R6, DELX2
	DJNZ R5, DELX1
	RET
DELY:	MOV R5,#08H
DELY1:	MOV R6,#0FFH
DELY2:	MOV R7,#0FFH
DELY3:	DJNZ R7, DELY3
	DJNZ R6, DELY2
	DJNZ R5, DELY1
	RET
DELZ:	MOV R5,#1FH
DELZ1:	MOV R6,#0FFH
DELZ2:	MOV R7,#0FFH
DELZ3:	DJNZ R7, DELZ3
	DJNZ R6, DELZ2
	DJNZ R5, DELZ1
	RET
	END
