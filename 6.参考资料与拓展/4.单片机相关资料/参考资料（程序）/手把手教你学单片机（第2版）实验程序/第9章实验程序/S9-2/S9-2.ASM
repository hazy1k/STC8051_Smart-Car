	ORG 0000H
	LJMP MAIN
	ORG 030H
MAIN:	MOV DPTR,#TAB
	MOV R1,#20H
	MOV R7,#20H
C01:	CLR A
	MOVC A,@A+DPTR
	MOV @R1,A
	INC DPTR
	INC R1
	DJNZ R7,C01
START:  MOV 60H,#00H
	MOV R7,#20H
	MOV R1,#20H
START1:	MOV A,@R1
	CJNE A,#58H,LOOP
	INC 60H
LOOP:	INC R1
	DJNZ R7,START1
	MOV P0,60H
	ACALL DEL
	SJMP $
	ORG 0100H
TAB:	DB 0FEH,25H,02H,0FEH,25H 
	DB 58H,25H,04H,0FDH,80H
	DB 0FAH,84H,02H,0FEH,84H
	DB 0FEH,84H,04H,0FEH,25H
	DB 58H,25H,02H,0FEH,84H
	DB 0FEH,0C0H,04H,0FEH,0C0H
	DB 0FBH,98H
	ORG 0150H
DEL:	MOV R5,#0BH		
F1:	MOV R7,#02H
F2:	MOV R6,#0FFH
F3:	DJNZ R6,F3
	DJNZ R7,F2
	DJNZ R5,F1
	RET
	END
