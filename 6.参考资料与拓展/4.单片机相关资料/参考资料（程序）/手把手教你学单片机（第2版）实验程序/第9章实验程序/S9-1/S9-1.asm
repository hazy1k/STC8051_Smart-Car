	ORG 0000H
	LJMP MAIN
	ORG 030H
MAIN:	MOV P0,#0C0H
	MOV P1,#0C0H
	MOV P2,#0C0H
	MOV R0,#00H
ST:	MOV P3,#0FH
	MOV A,P3
       	CJNE A,#0FH,F1
	ACALL DEL
	AJMP ST
F1:	ACALL DEL
	CJNE A,#0FH,F2
	AJMP ST
F2:	INC R0
	CJNE R0,#0AH,F3
	MOV R0,#00H
F3:	MOV DPTR,#JPTAB
	MOV A,R0
	CLR C
	RLC A
	JNC NADD
	INC DPH
NADD:	JMP @A+DPTR
JPTAB:	NOP
	NOP
	AJMP PR1
	AJMP PR2
	AJMP PR3
	AJMP PR4
	AJMP PR5
	AJMP PR6
	AJMP PR7
	AJMP PR8
	AJMP PR9
DEL: 	MOV R7,#014H
DEL1:	MOV R6,#0FFH
DEL2:   MOV R5,#01FH
DEL3:	DJNZ R5,DEL3
	DJNZ R6,DEL2
	DJNZ R7,DEL1
	RET
PR1:	MOV P0,#0F9H
	MOV P1,#0F9H
	MOV P2,#0F9H
	ACALL DEL
	AJMP ST
PR2:	MOV P0,#0A4H
	MOV P1,#0A4H
	MOV P2,#0A4H
	ACALL DEL
	AJMP ST
PR3:	MOV P0,#0B0H
	MOV P1,#0B0H
	MOV P2,#0B0H
	ACALL DEL
	AJMP ST
PR4:	MOV P0,#99H
	MOV P1,#99H
	MOV P2,#99H
	ACALL DEL
	AJMP ST
PR5:	MOV P0,#92H
	MOV P1,#92H
	MOV P2,#92H
	ACALL DEL
	AJMP ST
PR6:	MOV P0,#82H
	MOV P1,#82H
	MOV P2,#82H
	ACALL DEL
	AJMP ST
PR7:	MOV P0,#0F8H
	MOV P1,#0F8H
	MOV P2,#0F8H
	ACALL DEL
	AJMP ST
PR8:	MOV P0,#80H
	MOV P1,#80H
	MOV P2,#80H
	ACALL DEL
	AJMP ST
PR9:	MOV P0,#90H
	MOV P1,#90H
	MOV P2,#90H
	ACALL DEL
	AJMP ST
	END
