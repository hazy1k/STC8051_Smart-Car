		ORG 0000H
		AJMP MAIN
		ORG 0030H
MAIN:	MOV R0,#20H
		MOV R1,#30H
		MOV A,#10H
HERE1:MOV @R0,A
		INC R0
		INC A
		DJNZ R1,HERE1
		MOV R0,#20H
		;**************
		MOV DPTR,#0000H
		MOV R1,#30H
HERE2:MOV A,@R0
		MOVX @DPTR,A
 		INC R0
 		INC DPTR
 		DJNZ R1,HERE2
 		MOV R0,#30H
		;**************
 		MOV DPTR,#0000H
		MOV R1,#20H
HERE3:MOVX A,@DPTR
  		MOV @R0,A
 		INC R0
 		INC DPTR
 		DJNZ R1,HERE3
 		SJMP $
		END
