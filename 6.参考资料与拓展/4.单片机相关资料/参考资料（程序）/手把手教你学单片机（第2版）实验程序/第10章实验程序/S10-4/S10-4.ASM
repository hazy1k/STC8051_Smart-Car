	ORG 0000H
	LJMP MAIN
	ORG 030H
MAIN:	ORL P2,#0FH
GOON:	MOV A,P2
	MOV C,ACC.0
	ANL C,ACC.1
	ANL C,ACC.2
	ANL C,ACC.3
	MOV 00H,C
	MOV C,ACC.0
	ANL C,/ACC.1
	MOV 01H,C
	ANL C,/ACC.2
	ORL C, 00H
	MOV 00H,C
	MOV C,ACC.2
	ANL C,01H
	ANL C,/ACC.3
	ORL C, /00H
	MOV P2.7,C
	ACALL DEL
	SJMP GOON
DEL:	MOV R5,#04H
F3:	MOV R6,#0FFH
F2:	MOV R7,#0FFH
F1:	DJNZ R7,F1
	DJNZ R6,F2
	DJNZ R5,F3
	RET
	END
