	ORG 0000H
	LJMP MAIN
	ORG 030H
MAIN:	MOV P0,#0FFH
	MOV P1,#0FFH
	MOV P2,#0FFH
	MOV P3,#0FFH
	MOV A,P1
	CJNE A,P2,L1
	CLR P0.4
	ACALL DEL
	AJMP MAIN
L1:	JC L2
	CLR P0.7
	ACALL DEL
	AJMP MAIN
L2:	CLR P0.0
	ACALL DEL
	AJMP MAIN
DEL: 	MOV R7,#0FFH
DEL1:	MOV R6,#0FFH
DEL2:	DJNZ R6,DEL2
	DJNZ R7,DEL1
	RET
	END
